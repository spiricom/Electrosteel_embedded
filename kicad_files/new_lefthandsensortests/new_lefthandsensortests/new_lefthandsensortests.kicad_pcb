# Repository spiricom/Electrosteel_embedded

File README.md:

# Electrosteel_embedded
repository for embedded firmware and EAGLE design files for the Electrosteel

## KiCad design kicad_files/electrosteel2020_10_arrange5.kicad_pcb

Schematic: electrosteel2020_10_arrange5.kicad_sch

Parts:
+12VA0, +15VA0: PINHD-1X1; 1X01; PARTNO *DNP
-12VA0, -15VA0: PINHD-1X1; 1X01; PARTNO *DNP
AGND0: PINHD-1X1; 1X01; PARTNO *DNP
AGND_1, AGND_2: PINHD-1X1; 1X01; PARTNO *DNP
C1, C2, C3, C4, C5, C11, C12, C13, C14, C15, C20, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41, C42, C43, C44, C45, C46, C47, C48, C49, C50, C55, C56, C57, C60, C61, C62, C63, C70, C71, C72, C73, C74, C75, C76, C77, C78, C79, C80, C81, C82, C83, C84, C85, C86, C87, C88, C89, C90, C91, C92, C93, C94, C95, C96, C97, C98, C99, C100, C101, C102, C103, C104, C105, C106, C113, C117, C118, C122: .1uf; 0402; PARTNO CC0402KRX7R8BB104
C6, C7, C8, C9, C10, C51, C52, C53, C54, C58, C59, C66, C67, C68, C69, C116, C119, C120, C121: .01uf; C0201; PARTNO TMK063B7103KP-F
C16, C21, C64, C65: .01uf; 0402; PARTNO CC0402KRX7R8BB103
C17, C18: 18pf; C0603; PARTNO CL10C180JB8NNNC
C19, C123, C182: 2.2uf; C1206; PARTNO T491A225K020AT
C107, C110, C178, C179: .1uf; C0603; PARTNO CC0603KRX7R8BB104
C108, C111, C114, C175: 1uf; C1206; PARTNO C3216X7R1E105K085AA
C109, C112, C115, C174: 10uf; SMC_B; PARTNO TAJB106K025RNJ
C124, C127, C128, C133, C134, C136, C141, C142, C143, C144, C145, C146, C147, C148, C149, C150, C151, C152, C154, C156, C157, C164, C165, C166, C167, C172, C176, C180, C184, C188, C192, C196, C200, C204: .1uf; C0603K; PARTNO CC0603KRX7R8BB104
C125, C126, C131, C132, C137, C138, C139, C140, C159, C162, C163, C169, C170, C173, C177, C181, C185, C189, C193, C197, C201, C205: 1uf; C1206K; PARTNO C3216X7R1E105K085AA
C129, C130, C135, C153, C160, C161, C168: 10uf; C1206K; PARTNO TMK316F106ZL-T
C155: 2200pf; C0603K; PARTNO C0603C222J5GACTU
C158: 22uf; PANASONIC_D; PARTNO EEE-1CA220NP
C171: 220uf; E5-10,5; PARTNO ESW227M035AH9AA
D2, D3: MBRS30T3; SMC; PARTNO MBRS340T3G
DGND0, DGND1, DGND2, DGND3, DGND4, DGND5: PINHD-1X1; 1X01; PARTNO *DNP
HOUT1, HOUT3, HOUT5, HOUT7, HOUT9, HOUT11, HOUT13, HOUT15, HOUT17, HOUT19: PINHD-1X1; 1X01; PARTNO *DNP
IC1, IC7, IC8, IC9, IC10, IC17: OPA4E; TSSOP14; PARTNO OPA4348AQPWRQ1
IC2: LMV321?M5; SOT23-5; PARTNO LMV321M5
IC3: STM32H743ZIT6; QFP50P2200X2200X160-144N; PARTNO STM32H730ZBT6
IC4: LMV321?M5; SOT23-5; PARTNO LMV611MF/NOPB
IC5: 78LXX; PARTNO LM78L12ACZ/LFT7
IC6: 79LXX; PARTNO L79L12ACZ-TR
IC11: LP5912; 6-WSON; PARTNO LP5912-3.3DRVT
IC12, IC13, IC14, IC15, IC18, IC20: REG1117; SOT223; PARTNO LD1117S33TR
IC16: OPA4E; TSSOP14; PARTNO OPA1654AIPWR
J1, J32: AUDIO_JACK_TRS_0.25"_PTH_RA; AUDIO_JACK_0.25__TRS_PTH_RA; PARTNO NRJ6HM-1
J2, J3, J4, J5, J6, J7, J8, J10, J11, J12, J13, J14, J15, J16, J17, J18, J19, J20, J21, J22, J23, J24, J26, J34, J36, J38: 4P-2.0; HW4-2.0; PARTNO 110990030
J9, J25, J27, J29, J31, J33, J35, J37, J39, J41: 4P-2.0-90D; HW4-2.0-90D; PARTNO 110990037
J28: PJ-066A; CUI_PJ-066A; PARTNO PJ-066A
J42: J-20-100-2X10_M; DIL-100-2X10_M; PARTNO RS2-20-G
JP1, JP2, JP15: PINHD-1X4; 1X04
JP3, JP4, JP5: PINHD-2X4; 2X04; PARTNO 77313-101-08LF
JP6, JP7, JP8: PINHD-2X10; 2X10; PARTNO 77313-101-20LF
JP9, JP10, JP11: PINHD-2X15; 2X15; PARTNO 77313-101-30LF
JP12, JP13, JP14, JP17, JP18, JP20: PINHD-1X2; 1X02; PARTNO *DNP
JP19: PINHD-1X8; 1X08; PARTNO *DNP
JP21: PINHD-1X4; 1X04; PARTNO *DNP
LED1, LED3, LED4: RED; CHIP-LED0603; PARTNO 5973006507F
LED2: GREEN; CHIP-LED0603; PARTNO 5973506507F
LED5, LED7: GREEN; P-LCC-2; PARTNO HSMM-A101-R00J1
LED6, LED12: RED; P-LCC-2; PARTNO HSMZ-A100-R00J1
LED8, LED9, LED10, LED11: AMBER; P-LCC-2; PARTNO HSMU-A100-S00J1
OPT1_A0, OPT1_B0, OPT2_A0, OPT2_B0, OPT3_A0, OPT3_B0, OPT4_A0, OPT4_B0, OPT5_A0, OPT5_B0, OPT6_A0, OPT6_B0, OPT7_A0, OPT7_B0, OPT8_A0, OPT8_B0, OPT9_A0, OPT9_B0, OPT10_A0, OPT10_B0, OPT11_A0, OPT11_B0, OPT12_A0, OPT12_B0: PINHD-1X1; 1X01; PARTNO *DNP
OPT_PWR0: PINHD-1X1; 1X01; PARTNO *DNP
P1: P-10-100-2X05_M; DIL-100-2X05_M; PARTNO ESW-105-12-L-D
P2: P-24-100-2X12_M; DIL-100-2X12_M; PARTNO ESW-112-12-L-D
P3, P4: M-1X03-SIP-100-40Y; SIP-100-03-40Y; PARTNO *DNP
P5_2, P5_3, P6-7, P12-4, P20, P64, P65, P66: PINHD-1X1; 1X01; PARTNO *DNP
PA0, PA1, PA2, PA3, PA4, PA5, PA6, PA7: PINHD-1X1; 1X01; PARTNO *DNP
PB0, PB1, PB8, PB9: PINHD-1X1; 1X01; PARTNO *DNP
PC4, PC5: PINHD-1X1; 1X01; PARTNO *DNP
PD0, PD1, PD8, PD9, PD10, PD15: PINHD-1X1; 1X01; PARTNO *DNP
PGO1, PGO3, PGO5, PGO7, PGO9, PGO11, PGO13, PGO15, PGO17, PGO19: PINHD-1X1; 1X01; PARTNO *DNP
Q1: 25MHz; NX3225; PARTNO 7M-25.000MAAJ-T
R1, R3, R7, R12, R17, R19, R21, R23, R25, R27, R29, R31: 10k; RESC1608X60; PARTNO ESR03EZPF1002
R2, R6, R8, R16, R18, R20, R22, R24, R26, R28, R30, R32: 100R; RESC1608X60; PARTNO ESR03EZPJ101
R4: 47R; R0603; PARTNO ESR03EZPJ470
R5: 10k; R0603; PARTNO RC0402FR-0710KL
R9, R10, R13, R79, R104, R123, R129, R136, R137, R138, R139, R140, R141, R184: 560R; R0603; PARTNO ESR03EZPF5600
R11: 47k; R0603; PARTNO ESR03EZPJ473
R14, R15, R86, R87, R108, R132, R145, R146, R166, R174, R182, R190, R198, R206, R214, R222, R230: 0R_DNP; R0603; PARTNO *DNP
R33, R34, R38, R39, R45, R46, R50, R51, R55, R56, R60, R61, R66, R67, R71, R72, R76, R77, R88, R89, R93, R94, R98, R99: 20k; R0603; PARTNO ESR03EZPF2002
R35, R36, R40, R41, R47, R48, R52, R53, R57, R58, R63, R64, R68, R69, R73, R74, R78, R80, R90, R91, R95, R96, R100, R101: 820R; R0603; PARTNO RCS0603820RFKEA
R37, R42, R49, R54, R59, R65, R70, R75, R85, R92, R97, R102, R133: 0R; R0603; PARTNO RC0603JR-070RL
R43, R44: 100k; R0603; PARTNO ESR03EZPF1003
R62, R81, R83, R84, R112, R117, R118, R119, R121, R122, R124, R200, R201, R202, R207, R208, R209: 33R; R0201; PARTNO RC0201FR-0733RL
R82, R103, R110, R111, R185: 0R; R0603; PARTNO RCS06030000Z0EA
R105, R106, R107, R109: 33R; 0402; PARTNO RC0402FR-0733RL
R113, R114, R115, R120, R192, R193, R194, R199: 10k; R0603; PARTNO ESR03EZPF1002
R116, R130, R143, R144: 0R; R0603; PARTNO CRCW06030000Z0EAHP
R125, R134, R158, R159, R160, R161, R162, R167, R168, R169, R170, R175, R176, R177, R178, R183: 1k; R0603; PARTNO ESR03EZPF1001
R126, R127, R131, R163, R164, R165, R171, R172, R173, R179, R180, R181, R186, R187, R188, R189, R191, R195, R196, R197, R203, R204, R205, R211, R212, R213, R219, R220, R221, R227, R228, R229: 2k; R0603; PARTNO ERJ-PA3F2001V
R128, R135: 10k; R0603; PARTNO ESR03EZPF5600
R142, R147, R148, R149, R150, R151, R152, R153, R154, R155, R156, R157: 1.5k; R0603; PARTNO ESR03EZPJ152
S1, S2, S3, S4, S5, S6, S7, S8, S9, S10, S11, S12: MOMENTARY-SWITCH-SPST-PTH-6.0MM; TACTILE_SWITCH_PTH_6.0MM; PARTNO TL1105SPF160Q
SW1: PEC11R-4215F-S0024; PARTNO PEC11R-4215F-S0024
U1: CY8C5868AXI-LP035; TQFP-100-14X14MM; PARTNO CY8C5888AXI-LP096
U2: CY8C5868AXI-LP035; TQFP-100-14X14MM; PARTNO CY8C5468AXI-LP042
U3, U4, U5, U6, U7, U8, U9, U10, U11, U12, U13, U14: QRE1113; PARTNO QRE1113GR
U15, U17: R-78E5.0-1.0; DC-DC_CONVERTER_78XX; PARTNO R-78E5.0-1.0
U16: TEXAS_TPS2051B; TEXAS_SOT23-5; PARTNO TPS2051BDBVRG4
U19, U20: TCA9548APWR; SOP65P640X120-24N; PARTNO TCA9548APWR
U22, U23, U25, U27, U29, U31, U33, U35, U37, U39: AS5600; SOIC8-1.27-5X4MM; PARTNO AS5600-ASOM
U$1, U$2: RK09; PARTNO RK09L1220A1B
U$3: CMR0512S3C; PARTNO DPU01M-15
U$5: MCP3221; SOT23-5L; PARTNO MCP3221A7T-E/OT
U$6: SS-7188VS-A-FLS; SS-7188VS-A-FLS_RJ45; PARTNO SS-7188VS-A-FLS
U$9, U$10: P82B96DP,118; SO8; PARTNO P82B96TD*112
UNK3V3A0, UNK3V3A_0A0, UNK3V3A_0B0, UNK3V3A_0C0, UNK3V3A_1, UNK3V3A_2, UNK3V3D0, UNK3V3D1, UNK3V3D2, UNK5V0, UNK5V/1, UNK5VD1, UNK5VD2: PINHD-1X1; 1X01; PARTNO *DNP
VREGGND0: PINHD-1X1; 1X01; PARTNO *DNP
VREGIN0: PINHD-1X1; 1X01; PARTNO *DNP
X1, X2, X3: 3221-10-0300-00; PARTNO 4048
X4: GLX-S-88M; PARTNO GLX-S-88M
X5: 2524-; PAK100_2500-24; PARTNO DW-12-08-L-D-215
X6: 2520-; PAK100_2500-20; PARTNO N2520-6003-UG
X7, X9, X10, X11: 2516-; PAK100_2500-16; PARTNO D2516-6002-AR
X8: 2510-; PAK100_2500-10; PARTNO DW-05-08-L-D-215

Connections:
3V3A2: C124.1, C125.1, C152.1, C153.1, IC18.2 (VOUT), IC18.PAD, U1.65 (VDDA), UNK3V3A_2.1
3V3A4: C134.1, C135.1, C136.1, C137.1, IC14.2 (VOUT), IC14.PAD, P1.7, P3.1, P4.1, U2.65 (VDDA), UNK3V3A_1.1
3V3D2: C133.1, C148.1, C149.1, C150.1, C151.1, C154.1, C157.1, C161.1, IC20.2 (VOUT), IC20.PAD, U1.26 (VDDIO1), U1.37 (VDDD0), U1.50 (VDDIO3), U1.75 (VDDIO0), U1.88 (VDDD1), U1.100 (VDDIO2), UNK3V3D2.1, X3.1
3V3D3: C162.1, C164.1, C167.1, C168.1, IC15.2 (VOUT), IC15.PAD, J20.3, J21.3, J22.3, J23.3, J24.3, J26.3, R125.1, R134.2, R150.2, R151.2, U20.24 (VCC)
3V3D5: C128.1, C130.1, C141.1, C142.1, C143.1, C144.1, C145.1, C146.1, C165.1, C169.1, IC13.2 (VOUT), IC13.PAD, J3.3, J4.3, J5.3, J6.3, J7.3, P1.8, P2.22, R142.2, R147.2, R148.2, R149.2, R158.2, U2.26 (VDDIO1), U2.37 (VDDD0), U2.50 (VDDIO3), U2.75 (VDDIO0), U2.88 (VDDD1), U2.100 (VDDIO2), U19.24 (VCC), UNK3V3D1.1, X1.1; also elsewhere on the board
5VD2: C156.1, C160.1, IC18.3 (VIN), IC20.3 (VIN), J16.1, J16.2, UNK5VD2.1
5VD4: C127.1, C129.1, C166.1, IC13.3 (VIN), IC14.3 (VIN), J18.1, J18.2, J19.1, J19.2, R152.2, R153.2, R154.2, R155.2, U15.VOUT (OUT), U$9.8 (VCC), UNK5VD1.1, X4.2, X4.6
12VD2: C171.+, D2.C, U15.VIN (IN), X9.1, X9.3
+3V3: C1.1, C2.1, C3.1, C4.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C20.1, C55.1, C63.1, C66.1, C67.1, C68.1, C69.1, C107.1, C108.1, C109.+, D3.C, IC3.6 (VBAT), IC3.17 (VDD), IC3.30 (VDD), IC3.39 (VDD), IC3.52 (VDD), IC3.62 (VDD), IC3.72 (VDD), IC3.84 (VDD), IC3.95 (VDD33USB), IC3.108 (VDD), IC3.121 (VDD), IC3.131 (VDD), IC3.143 (PDR_ON), IC3.144 (VDD), IC11.4 (EN), IC12.2 (VOUT), IC12.PAD, R104.1, UNK3V3D0.1, X2.1
+5V: C114.1, C115.+, IC11.6 (IN), IC12.3 (VIN), J17.1, J17.2, UNK5V0.1
+5V/1: C117.1, C119.1, JP6.19, JP7.19, JP8.19, R14.2, U17.VOUT (OUT), UNK5V/1.1
+9V: +12VA0.1, C47.1, C51.1, C56.1, C58.1, IC5.OUT, IC16.4 (V+)
+12V: C118.1, C120.1, R110.2, U17.VIN (IN), X7.1, X7.3
-9V: -12VA0.1, C48.2, C52.2, C57.2, C59.2, IC6.OUT, IC16.11 (V-)
A10: IC3.56 (PG0)
A11: IC3.57 (PG1)
A12: IC3.87 (PG2)
AGND: AGND0.1, C32.2, C42.2, C44.2, C46.2, C64.2, C65.2, C100.2, C102.2, C104.2, C106.2, C110.2, C111.2, C112.-, C113.2, C116.2, IC1.11 (V-), IC3.31 (VSSA), IC4.2 (V-), IC7.11 (V-), IC8.11 (V-), IC9.11 (V-), IC10.11 (V-), IC11.5 (GND), IC11.PAD, IC17.11 (V-), R44.1, R103.2, X11.13, X11.15
AGND2: AGND_2.1, C124.2, C125.2, C126.2, C152.2, C153.2, C163.2, IC18.1 (GND), J42.13, J42.14, J42.15, J42.16, R116.1, U1.64 (VSSA)
AGND3: JP12.2, JP13.2, JP17.2, JP18.2, X6.13, X6.14, X6.15, X6.16
AGND4: AGND_1.1, C134.2, C135.2, C136.2, C137.2, C138.2, C170.2, IC14.1 (GND), P1.6, P3.3, P4.3, R130.1, U2.64 (VSSA)
AGND5: C47.2, C48.1, C49.1, C50.2, C51.2, C52.1, C53.2, C54.1, C56.2, C57.1, C58.2, C59.1, IC5.GND, IC6.GND, IC16.3 (+IN), IC16.5 (+IN), IC16.10 (+IN), IC16.12 (+IN), J36.3, J36.4, JP3.3, JP3.4, JP3.5, JP3.6, JP4.3, JP4.4, JP4.5, JP4.6, JP5.3, JP5.4, JP5.5, JP5.6, JP14.2, R11.1, R185.2, U$3.P$4 (0)
A_IN1: JP3.2, R184.2
A_IN2: JP4.2, R13.2
A_IN3: JP5.2, R9.2
A_OUT1: JP3.8, R160.1, R167.1, R177.1
A_OUT2: JP4.8, R161.1, R168.1, R170.1
A_OUT3: JP5.8, R162.1, R175.1, R178.1
BOTTOMWIPER1: R114.1, U1.77 (P0[5])
BOTTOMWIPER2: J42.20, U1.78 (P0[6])
CGND: C15.2, C16.2, C21.2, C22.2, C123.2, C182.2, DGND4.1, U3.2 (K), U3.4 (E), U4.2 (K), U4.4 (E), U5.2 (K), U5.4 (E), U6.2 (K), U6.4 (E), U7.2 (K), U7.4 (E), U8.2 (K), U8.4 (E), U9.2 (K), U9.4 (E), U10.2 (K), U10.4 (E), U11.2 (K), U11.4 (E), U12.2 (K), U12.4 (E), U13.2 (K), U13.4 (E), U14.2 (K), U14.4 (E), U16.2 (GND), X10.13, X10.15
CMOD: C155.1, U1.93 (P15[4])
DGND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C17.2, C18.2, C19.2, C20.2, C55.2, C63.2, C66.2, C67.2, C68.2, C69.2, C107.2, C108.2, C109.-, C114.2, C115.-, DGND0.1, DGND1.1, IC3.16 (VSS), IC3.38 (VSS), IC3.51 (VSS), IC3.61 (VSS), IC3.83 (VSS), IC3.94 (VSS), IC3.107 (VSS), IC3.120 (VSS), IC3.130 (VSS), IC12.1 (GND), J17.3, J17.4, LED1.C, LED2.C, Q1.2 (G2), Q1.4 (G1), R5.2, R103.1, X2.3, X2.5, X2.7, X2.9
DGND2: C131.2, C132.2, C133.2, C148.2, C149.2, C150.2, C151.2, C154.2, C155.2, C156.2, C157.2, C160.2, C161.2, DGND3.1, IC20.1 (GND), J16.3, J16.4, LED3.C, R116.2, U1.10 (VSSB), U1.12 (VBOOST), U1.13 (VBAT), U1.14 (VSSD0), U1.38 (VSSD1), U1.66 (VSSD2), U1.87 (VSSD3), X3.3, X3.5, X3.7, X3.9
DGND4: C117.2, C118.2, C119.2, C120.2, DGND5.1, JP6.20, JP7.20, JP8.20, JP9.22, JP9.24, JP10.24, JP11.22, R15.2, R111.2, R185.1, U17.GND, X7.2, X7.4
DGND5: C127.2, C128.2, C129.2, C130.2, C139.2, C140.2, C141.2, C142.2, C143.2, C144.2, C145.2, C146.2, C165.2, C166.2, C169.2, C171.-, DGND2.1, IC13.1 (GND), J3.4, J4.4, J5.4, J6.4, J7.4, J18.3, J18.4, J19.3, J19.4, J28.2, JP19.8, LED4.C, P1.9, P1.10, P2.13, R130.2, R157.1, U2.10 (VSSB), U2.12 (VBOOST), U2.13 (VBAT), U2.14 (VSSD0), U2.38 (VSSD1), U2.66 (VSSD2), U2.87 (VSSD3), U15.GND, U19.1 (A0), U19.2 (A1), U19.12 (GND), U19.21 (A2), U$9.4 (GND), X1.3, X1.5, X1.7, X1.9, X4.5, X4.8, X4.S1, X4.S2, X9.2, X9.4
DM: JP19.4, U2.36 (P15[7])
DP: JP19.3, U2.35 (P15[6])
EGND: R128.2, R129.2, R135.2, R136.2, R137.2, R139.2, R140.2, R141.2, R144.2, R146.1, S1.3 (2), S2.3 (2), S3.3 (2), S4.3 (2), S5.3 (2), S6.3 (2), S7.3 (2), S8.3 (2), S9.3 (2), S10.3 (2), S11.3 (2), S12.3 (2), SW1.2, SW1.C (COM), X5.13, X8.9, X8.10
GND-ISO: C162.2, C164.2, C167.2, C168.2, IC15.1 (GND), J20.4, J21.4, J22.4, J23.4, J24.4, J26.4, R133.1, U20.2 (A1), U20.12 (GND), U20.21 (A2), U$6.P$5 (5), U$6.P$8 (8), U$10.4 (GND)
I2C2_SCL: IC3.69 (PB10)
I2C2_SDA: IC3.70 (PB11)
MIDBOTTOMWIPER1: R120.2, U1.83 (P4[5])
MIDBOTTOMWIPER2: J42.17, U1.79 (P0[7])
MIDDLEWIPER1: R115.1, U1.45 (P3[1])
MIDDLEWIPER2: J42.18, U1.80 (P4[2])
MSPI1_MISO: J11.3, U1.27 (P1[6])
MSPI1_MOSI: J11.4, R119.1
MSPI1_NSS: J11.2, R118.1
MSPI1_SCK: J11.1, R117.1
MSPI2_MISO: J12.3, U1.33 (P5[6])
MSPI2_MOSI: J12.4, R124.1
MSPI2_NSS: J12.2, R122.1
MSPI2_SCK: J12.1, R121.1
unnamed: R6.1, U4.1 (A)
unnamed: R2.1, U3.1 (A)
unnamed: IC3.77 (PD8), PD8.1
unnamed: IC3.78 (PD9), PD9.1
unnamed: LED2.A, R79.2
unnamed: IC3.134 (PB4(~JTRST)), R79.1
unnamed: R8.1, U5.1 (A)
unnamed: IC3.4 (PE5), R81.2
unnamed: J42.1, U1.3 (P2[7])
unnamed: IC16.6 (-IN), R167.2, R168.2, R169.1
unnamed: JP17.1, X6.19
unnamed: JP18.1, X6.20
unnamed: IC3.3 (PE4), R83.2
unnamed: JP13.1, X6.18
unnamed: JP12.1, X6.17
unnamed: LED3.A, R123.2
unnamed: IC3.5 (PE6), R84.2
unnamed: R123.1, U1.17 (P5[1])
unnamed: IC3.1 (PE2), R62.2
unnamed: P5_2.1, U1.18 (P5[2])
unnamed: P5_3.1, U1.19 (P5[3])
unnamed: C138.1, U2.63 (VCCA)
unnamed: C170.1, U2.76 (P0[4])
unnamed: J42.2, U1.2 (P2[6])
unnamed: J42.3, U1.1 (P2[5])
unnamed: D2.A, J28.1
unnamed: IC16.2 (-IN), R159.1, R160.2, R161.2, R162.2
unnamed: IC16.7 (OUT), R9.1, R169.2
unnamed: IC16.9 (-IN), R177.2, R178.2, R183.1
unnamed: +15VA0.1, C50.1, C53.1, IC5.IN, U$3.P$5 (12VOUT)
unnamed: C60.1, C61.2, R55.1
unnamed: C158.+, IC16.1 (OUT), R159.2
unnamed: R16.1, U6.1 (A)
unnamed: -15VA0.1, C49.2, C54.2, IC6.IN, U$3.P$3 (-12VOUT)
unnamed: R18.1, U7.1 (A)
unnamed: R20.1, U8.1 (A)
unnamed: R22.1, U9.1 (A)
unnamed: R24.1, U14.1 (A)
unnamed: R26.1, U10.1 (A)
unnamed: R28.1, U11.1 (A)
unnamed: R30.1, U12.1 (A)
unnamed: R32.1, U13.1 (A)
unnamed: C27.1, C28.2, R38.1
unnamed: IC3.138 (BOOT0), R5.1
unnamed: C28.1, IC17.10 (+IN), R39.2
unnamed: IC17.8 (OUT), IC17.9 (-IN), R38.2, R40.2
unnamed: C29.1, IC17.12 (+IN), R41.1
unnamed: C30.1, R40.1, R41.2
unnamed: C33.1, C34.2, R45.1
unnamed: C34.1, IC1.3 (+IN), R46.2
unnamed: IC1.1 (OUT), IC1.2 (-IN), R45.2, R47.2
unnamed: C35.1, IC1.5 (+IN), R48.1
unnamed: C36.1, R47.1, R48.2
unnamed: C37.1, C38.2, R50.1
unnamed: C38.1, IC1.10 (+IN), R51.2
unnamed: IC1.8 (OUT), IC1.9 (-IN), R50.2, R52.2
unnamed: C39.1, IC1.12 (+IN), R53.1
unnamed: C40.1, R52.1, R53.2
unnamed: C61.1, IC7.3 (+IN), R56.2
unnamed: IC7.1 (OUT), IC7.2 (-IN), R55.2, R57.2
unnamed: LED1.A, R104.2
unnamed: C62.1, IC7.5 (+IN), R58.1
unnamed: C70.1, R57.1, R58.2
unnamed: C71.1, C72.2, R60.1
unnamed: C72.1, IC7.10 (+IN), R61.2
unnamed: IC7.8 (OUT), IC7.9 (-IN), R60.2, R63.2
unnamed: C73.1, IC7.12 (+IN), R64.1
unnamed: C23.1, C24.2, R34.1
unnamed: C24.1, IC17.3 (+IN), R33.2
unnamed: C74.1, R63.1, R64.2
unnamed: IC17.1 (OUT), IC17.2 (-IN), R34.2, R35.2
unnamed: C26.1, IC17.5 (+IN), R36.1
unnamed: C25.1, R35.1, R36.2
unnamed: C75.1, C76.2, R66.1
unnamed: C76.1, IC8.3 (+IN), R67.2
unnamed: IC8.1 (OUT), IC8.2 (-IN), R66.2, R68.2
unnamed: C77.1, IC8.5 (+IN), R69.1
unnamed: C78.1, R68.1, R69.2
unnamed: C79.1, C80.2, R71.1
unnamed: C80.1, IC8.10 (+IN), R72.2
unnamed: IC8.8 (OUT), IC8.9 (-IN), R71.2, R73.2
unnamed: C81.1, IC8.12 (+IN), R74.1
unnamed: C82.1, R73.1, R74.2
unnamed: C83.1, C84.2, R76.1
unnamed: C84.1, IC9.3 (+IN), R77.2
unnamed: IC9.1 (OUT), IC9.2 (-IN), R76.2, R78.2
unnamed: C85.1, IC9.5 (+IN), R80.1
unnamed: C86.1, R78.1, R80.2
unnamed: C87.1, C88.2, R88.1
unnamed: C88.1, IC9.10 (+IN), R89.2
unnamed: IC9.8 (OUT), IC9.9 (-IN), R88.2, R90.2
unnamed: C89.1, IC9.12 (+IN), R91.1
unnamed: C90.1, R90.1, R91.2
unnamed: C91.1, C92.2, R93.1
unnamed: C92.1, IC10.3 (+IN), R94.2
unnamed: IC10.1 (OUT), IC10.2 (-IN), R93.2, R95.2
unnamed: C93.1, IC10.5 (+IN), R96.1
unnamed: C94.1, R95.1, R96.2
unnamed: C95.1, C96.2, R98.1
unnamed: C96.1, IC10.10 (+IN), R99.2
unnamed: IC10.8 (OUT), IC10.9 (-IN), R98.2, R100.2
unnamed: C97.1, IC10.12 (+IN), R101.1
unnamed: C98.1, R100.1, R101.2
unnamed: C31.2, C32.1, IC4.1 (+IN), R43.1, R44.2
unnamed: C121.2, C122.2, R15.1, R111.1, U$3.P$2 (VIN-), VREGGND0.1
unnamed: C121.1, C122.1, R14.1, R110.1, U$3.P$1 (VIN+), VREGIN0.1
unnamed: J42.4, U1.99 (P2[4])
unnamed: J42.5, U1.98 (P2[3])
unnamed: J42.6, U1.6 (P6[4])
unnamed: J42.7, U1.7 (P6[5])
unnamed: C126.1, U1.63 (VCCA)
unnamed: J42.8, U1.8 (P6[6])
unnamed: J42.11, U1.97 (P2[2])
unnamed: J42.9, U1.9 (P6[7])
unnamed: J42.10, U1.95 (P2[0])
unnamed: C163.1, U1.46 (P3[2])
unnamed: IC3.79 (PD10), PD10.1
unnamed: IC3.86 (PD15), PD15.1
unnamed: J42.12, U1.96 (P2[1])
unnamed: R117.2, U1.24 (P1[4])
unnamed: R118.2, U1.25 (P1[5])
unnamed: R119.2, U1.28 (P1[7])
unnamed: J3.1, U19.5 (SC0)
unnamed: R121.2, U1.31 (P5[4])
unnamed: R122.2, U1.32 (P5[5])
unnamed: J3.2, U19.4 (SD0)
unnamed: R124.2, U1.34 (P5[7])
unnamed: J4.1, U19.7 (SC1)
unnamed: J4.2, U19.6 (SD1)
unnamed: J5.1, U19.9 (SC2)
unnamed: J5.2, U19.8 (SD2)
unnamed: J6.1, U19.11 (SC3)
unnamed: J6.2, U19.10 (SD3)
unnamed: J7.1, U19.14 (SC4)
unnamed: J7.2, U19.13 (SD4)
unnamed: R125.2, U20.1 (A0)
unnamed: J20.1, U20.5 (SC0)
unnamed: J20.2, U20.4 (SD0)
unnamed: J21.1, U20.7 (SC1)
unnamed: J21.2, U20.6 (SD1)
unnamed: J22.1, U20.9 (SC2)
unnamed: J22.2, U20.8 (SD2)
unnamed: J23.1, U20.11 (SC3)
unnamed: LED4.A, R138.2
unnamed: S1.1, X5.1
unnamed: J23.2, U20.10 (SD3)
unnamed: J24.1, U20.14 (SC4)
unnamed: J24.2, U20.13 (SD4)
unnamed: U$6.P$4 (4), U$10.3 (TX(SDA))
unnamed: R150.1, U20.23 (SDA), U$10.1 (SX(SDA))
unnamed: U$6.P$1 (1), U$10.5 (TY(SCL))
unnamed: R126.1, R132.2, U22.8 (DIR)
unnamed: J25.2, R131.2, U22.6 (SDA)
unnamed: J25.1, R127.2, U22.7 (SCL)
unnamed: C147.1, C159.1, J25.3, R126.2, R127.1, R131.1, U22.1 (VDD5V), U22.2 (VDD3V3)
unnamed: C147.2, C159.2, J25.4, R132.1, U22.4 (GND)
unnamed: PGO1.1, U22.5 (PGO)
unnamed: J26.1, U20.16 (SC5)
unnamed: J26.2, U20.15 (SD5)
unnamed: HOUT1.1, U22.3 (OUT)
unnamed: R207.2, U2.43 (P15[1])
unnamed: R200.2, U2.44 (P3[0])
unnamed: S2.1, X5.2
unnamed: S3.1, X5.3
unnamed: R153.1, U$9.5 (TY(SCL)), X4.3
unnamed: S4.1, X5.4
unnamed: R154.1, U$9.2 (RX(SDA)), X4.4
unnamed: R155.1, U$9.3 (TX(SDA)), X4.7
unnamed: U$6.P$3 (3), U$10.6 (RY(SCL))
unnamed: U$6.P$7 (7), U$10.2 (RX(SDA))
unnamed: R133.2, U$6.P$9 (S1), U$6.P$10 (S2)
unnamed: R151.1, U20.22 (SCL), U$10.7 (SY(SCL))
unnamed: R134.1, U20.3 (~RESET)
unnamed: R152.1, U$9.6 (RY(SCL)), X4.1
unnamed: S5.1, X5.5
unnamed: IC15.3 (VIN), U$6.P$2 (2), U$6.P$6 (6), U$10.8 (VCC)
unnamed: S6.1, X5.6
unnamed: S7.1, X5.7
unnamed: S8.1, X5.8
unnamed: S9.1, X5.9
unnamed: S12.1, X5.10
unnamed: S10.1, X5.11
unnamed: S11.1, X5.12
unnamed: R148.1, U19.16 (SC5), U$9.7 (SY(SCL))
unnamed: LED5.A, X5.14
unnamed: LED6.A, X5.15
unnamed: LED7.A, X5.16
unnamed: LED8.A, X5.17
unnamed: LED9.A, X5.18
unnamed: LED10.A, X5.19
unnamed: LED11.A, X5.20
unnamed: LED12.A, X5.21
unnamed: R149.1, U19.15 (SD5), U$9.1 (SX(SDA))
unnamed: LED5.C, R128.1
unnamed: LED6.C, R129.1
unnamed: LED7.C, R135.1
unnamed: LED8.C, R136.1
unnamed: LED9.C, R137.1
unnamed: LED10.C, R139.1
unnamed: LED11.C, R140.1
unnamed: LED12.C, R141.1
unnamed: P2.23, R142.1, U19.18 (SC6)
unnamed: U$1.2-09 (2), X8.1
unnamed: U$2.2-09 (2), X8.2
unnamed: SW1.A, X8.3
unnamed: SW1.B, X8.4
unnamed: SW1.1, X8.5
unnamed: U$1.3-09 (3), U$2.3-09 (3), X8.6
unnamed: U$1.1-09 (1), U$2.1-09 (1), X8.7
unnamed: JP21.3, X5.23
unnamed: JP21.4, X5.24
unnamed: JP21.1, R143.1, R146.2
unnamed: JP21.2, R144.1, R145.2
unnamed: R143.2, R145.1, X5.22, X8.8
unnamed: P2.24, R147.1, U19.17 (SD6)
unnamed: P1.1, U2.71 (P0[0])
unnamed: P1.2, U2.72 (P0[1])
unnamed: P3.2, U2.73 (P0[2])
unnamed: P4.2, U2.74 (P0[3])
unnamed: P1.3, U2.80 (P4[2])
unnamed: P1.4, U2.81 (P4[3])
unnamed: P1.5, U2.34 (P5[7])
unnamed: R158.1, U19.3 (~RESET)
unnamed: R138.1, U2.33 (P5[6])
unnamed: P2.1, U2.32 (P5[5])
unnamed: P2.2, U2.31 (P5[4])
unnamed: P2.3, U2.28 (P1[7])
unnamed: P2.4, U2.27 (P1[6])
unnamed: P2.5, U2.25 (P1[5])
unnamed: P2.6, U2.24 (P1[4])
unnamed: P2.7, U2.23 (P1[3])
unnamed: P2.8, U2.22 (P1[2])
unnamed: P2.21, U2.51 (P3[6])
unnamed: P2.20, U2.52 (P3[7])
unnamed: P2.19, U2.53 (P12[0])
unnamed: P2.18, U2.54 (P12[1])
unnamed: P2.9, U2.99 (P2[4])
unnamed: P2.10, U2.98 (P2[3])
unnamed: P2.11, U2.97 (P2[2])
unnamed: P2.12, U2.96 (P2[1])
unnamed: P2.14, U2.67 (P12[2])
unnamed: P2.15, U2.68 (P12[3])
unnamed: P2.16, U2.69 (P4[0])
unnamed: P2.17, U2.70 (P4[1])
unnamed: IC16.8 (OUT), R13.1, R183.2
unnamed: J38.1, R186.2, U$5.5 (SCL)
unnamed: J38.2, R191.2, U$5.4 (SDA)
unnamed: C158.-, R10.1
unnamed: C174.+, C175.1, C178.1, C179.1, IC2.5 (V+), J38.3, R186.1, R191.1, R194.2, U$5.1 (VDD)
unnamed: IC16.14 (OUT), R176.2, R184.1
unnamed: IC16.13 (-IN), R170.2, R175.2, R176.1
unnamed: R163.1, R166.2, U23.8 (DIR)
unnamed: J9.2, R165.2, U23.6 (SDA)
unnamed: J9.1, R164.2, U23.7 (SCL)
unnamed: C172.1, C173.1, J9.3, R163.2, R164.1, R165.1, U23.1 (VDD5V), U23.2 (VDD3V3)
unnamed: C172.2, C173.2, J9.4, R166.1, U23.4 (GND)
unnamed: PGO3.1, U23.5 (PGO)
unnamed: HOUT3.1, U23.3 (OUT)
unnamed: IC2.3 (-IN), R192.2, R193.2
unnamed: IC2.4 (OUT), J32.RING, J32.TIP-NORM, R193.1
unnamed: J1.SLEEVE (EARTH), J34.3, J34.4, JP20.2
unnamed: J1.TIP, J34.1, J34.2, JP20.1
unnamed: J36.1, J36.2, JP14.1, R10.2, R11.2
unnamed: C174.-, C175.2, C178.2, C179.2, IC2.2 (V-), J32.SLEEVE (EARTH), J38.4, R192.1, R199.1, U$5.2 (VSS)
unnamed: J32.TIP, U$5.3 (AIN)
unnamed: IC2.1 (+IN), R194.1, R199.2
unnamed: R171.1, R174.2, U25.8 (DIR)
unnamed: J27.2, R173.2, U25.6 (SDA)
unnamed: J27.1, R172.2, U25.7 (SCL)
unnamed: C176.1, C177.1, J27.3, R171.2, R172.1, R173.1, U25.1 (VDD5V), U25.2 (VDD3V3)
unnamed: C176.2, C177.2, J27.4, R174.1, U25.4 (GND)
unnamed: PGO5.1, U25.5 (PGO)
unnamed: HOUT5.1, U25.3 (OUT)
unnamed: R201.2, U2.45 (P3[1])
unnamed: IC3.112 (PC11), R202.2
unnamed: IC3.114 (PD0), PD0.1
unnamed: IC3.115 (PD1), PD1.1
unnamed: P64.1, U2.6 (P6[4])
unnamed: P65.1, U2.7 (P6[5])
unnamed: P66.1, U2.8 (P6[6])
unnamed: R209.2, X7.15
unnamed: R179.1, R182.2, U27.8 (DIR)
unnamed: J29.2, R181.2, U27.6 (SDA)
unnamed: J29.1, R180.2, U27.7 (SCL)
unnamed: C180.1, C181.1, J29.3, R179.2, R180.1, R181.1, U27.1 (VDD5V), U27.2 (VDD3V3)
unnamed: C180.2, C181.2, J29.4, R182.1, U27.4 (GND)
unnamed: PGO7.1, U27.5 (PGO)
unnamed: HOUT7.1, U27.3 (OUT)
unnamed: R208.2, X7.11
unnamed: R112.2, X7.7
unnamed: P6-7.1, U2.9 (P6[7])
unnamed: P12-4.1, U2.4 (P12[4])
unnamed: P20.1, U2.95 (P2[0])
unnamed: JP1.4, JP9.13
unnamed: JP9.12, UNK3V3A_0C0.1
unnamed: JP1.2, JP9.15
unnamed: R187.1, R190.2, U29.8 (DIR)
unnamed: J31.2, R189.2, U29.6 (SDA)
unnamed: J31.1, R188.2, U29.7 (SCL)
unnamed: C184.1, C185.1, J31.3, R187.2, R188.1, R189.1, U29.1 (VDD5V), U29.2 (VDD3V3)
unnamed: C184.2, C185.2, J31.4, R190.1, U29.4 (GND)
unnamed: PGO9.1, U29.5 (PGO)
unnamed: HOUT9.1, U29.3 (OUT)
unnamed: JP10.12, UNK3V3A_0A0.1
unnamed: JP11.12, UNK3V3A_0B0.1
unnamed 359: U19.19 (SD7); also elsewhere on the board
unnamed 360: U19.20 (SC7); also elsewhere on the board
unnamed: R195.1, R198.2, U31.8 (DIR)
unnamed: J33.2, R197.2, U31.6 (SDA)
unnamed: J33.1, R196.2, U31.7 (SCL)
unnamed: C188.1, C189.1, J33.3, R195.2, R196.1, R197.1, U31.1 (VDD5V), U31.2 (VDD3V3)
unnamed: C188.2, C189.2, J33.4, R198.1, U31.4 (GND)
unnamed: PGO11.1, U31.5 (PGO)
unnamed: HOUT11.1, U31.3 (OUT)
unnamed: R203.1, R206.2, U33.8 (DIR)
unnamed: J35.2, R205.2, U33.6 (SDA)
unnamed: J35.1, R204.2, U33.7 (SCL)
unnamed: C192.1, C193.1, J35.3, R203.2, R204.1, R205.1, U33.1 (VDD5V), U33.2 (VDD3V3)
unnamed: C192.2, C193.2, J35.4, R206.1, U33.4 (GND)
unnamed: PGO13.1, U33.5 (PGO)
unnamed: HOUT13.1, U33.3 (OUT)
unnamed: R211.1, R214.2, U35.8 (DIR)
unnamed: J37.2, R213.2, U35.6 (SDA)
unnamed: J37.1, R212.2, U35.7 (SCL)
unnamed: C196.1, C197.1, J37.3, R211.2, R212.1, R213.1, U35.1 (VDD5V), U35.2 (VDD3V3)
unnamed: C196.2, C197.2, J37.4, R214.1, U35.4 (GND)
unnamed: PGO15.1, U35.5 (PGO)
unnamed: HOUT15.1, U35.3 (OUT)
unnamed: R219.1, R222.2, U37.8 (DIR)
unnamed: J39.2, R221.2, U37.6 (SDA)
unnamed: J39.1, R220.2, U37.7 (SCL)
unnamed: C200.1, C201.1, J39.3, R219.2, R220.1, R221.1, U37.1 (VDD5V), U37.2 (VDD3V3)
unnamed: C200.2, C201.2, J39.4, R222.1, U37.4 (GND)
unnamed: PGO17.1, U37.5 (PGO)
unnamed: HOUT17.1, U37.3 (OUT)
unnamed: R227.1, R230.2, U39.8 (DIR)
unnamed: J41.2, R229.2, U39.6 (SDA)
unnamed: J41.1, R228.2, U39.7 (SCL)
unnamed: C204.1, C205.1, J41.3, R227.2, R228.1, R229.1, U39.1 (VDD5V), U39.2 (VDD3V3)
unnamed: C204.2, C205.2, J41.4, R230.1, U39.4 (GND)
unnamed: PGO19.1, U39.5 (PGO)
unnamed: HOUT19.1, U39.3 (OUT)
OPT1: R1.1, U3.3 (C), X10.1
OPT1_A: C23.2, OPT1_A0.1, X11.1
OPT1_B: C25.2, IC17.6 (-IN), IC17.7 (OUT), OPT1_B0.1, R37.2
OPT2: R3.1, U4.3 (C), X10.2
OPT2_A: C27.2, OPT2_A0.1, X11.2
OPT2_B: C30.2, IC17.13 (-IN), IC17.14 (OUT), OPT2_B0.1, R42.2
OPT3: R7.1, U5.3 (C), X10.3
OPT3_A: C33.2, OPT3_A0.1, X11.3
OPT3_B: C36.2, IC1.6 (-IN), IC1.7 (OUT), OPT3_B0.1, R49.2
OPT4: R12.1, U6.3 (C), X10.4
OPT4_A: C37.2, OPT4_A0.1, X11.4
OPT4_B: C40.2, IC1.13 (-IN), IC1.14 (OUT), OPT4_B0.1, R54.2
OPT5: R17.1, U7.3 (C), X10.5
OPT5_A: C60.2, OPT5_A0.1, X11.5
OPT5_B: C70.2, IC7.6 (-IN), IC7.7 (OUT), OPT5_B0.1, R59.2
OPT6: R19.1, U8.3 (C), X10.6
OPT6_A: C71.2, OPT6_A0.1, X11.6
OPT6_B: C74.2, IC7.13 (-IN), IC7.14 (OUT), OPT6_B0.1, R65.2
OPT7: R21.1, U9.3 (C), X10.7
OPT7_A: C75.2, OPT7_A0.1, X11.7
OPT7_B: C78.2, IC8.6 (-IN), IC8.7 (OUT), OPT7_B0.1, R70.2
OPT8: R25.1, U10.3 (C), X10.8
OPT8_A: C79.2, OPT8_A0.1, X11.8
OPT8_B: C82.2, IC8.13 (-IN), IC8.14 (OUT), OPT8_B0.1, R75.2
OPT9: R27.1, U11.3 (C), X10.9
OPT9_A: C83.2, OPT9_A0.1, X11.9
OPT9_B: C86.2, IC9.6 (-IN), IC9.7 (OUT), OPT9_B0.1, R85.2
OPT10: R29.1, U12.3 (C), X10.10
OPT10_A: C87.2, OPT10_A0.1, X11.10
OPT10_B: C90.2, IC9.13 (-IN), IC9.14 (OUT), OPT10_B0.1, R92.2
OPT11: R31.1, U13.3 (C), X10.11
OPT11_A: C91.2, OPT11_A0.1, X11.11
OPT11_B: C94.2, IC10.6 (-IN), IC10.7 (OUT), OPT11_B0.1, R97.2
OPT12: R23.1, U14.3 (C), X10.12
OPT12_A: C95.2, OPT12_A0.1, X11.12
OPT12_B: C98.2, IC10.13 (-IN), IC10.14 (OUT), OPT12_B0.1, R102.2
OPT_PWR: C21.1, C22.1, C123.1, R1.2, R3.2, R7.2, R12.2, R17.2, R19.2, R21.2, R23.2, R25.2, R27.2, R29.2, R31.2, U16.5 (IN), X10.14
OPT_PWR_EN: U16.4 (EN), X10.16
OPT_PWR_EN_A: IC3.55 (PF15), X11.16
OPT_PWR_SW: C15.1, C16.1, C182.1, OPT_PWR0.1, R2.2, R6.2, R8.2, R16.2, R18.2, R20.2, R22.2, R24.2, R26.2, R28.2, R30.2, R32.2, U16.1 (OUT)
OSC1: C17.1, IC3.23 (PH0/OSC_IN), Q1.1 (X1)
OSC2: C18.1, IC3.24 (PH1/OSC_OUT), Q1.3 (X2)
PA0: IC3.34 (PA0), PA0.1, R37.1
PA0-2: JP2.4, JP10.13
PA0-3: JP11.13, JP15.4
PA1: IC3.35 (PA1), PA1.1, R42.1
PA1-2: JP2.3, JP10.14
PA1-3: JP11.14, JP15.3
PA1_1: JP1.3, JP9.14
PA2: IC3.36 (PA2), PA2.1, R49.1
PA2-2: JP2.2, JP10.15
PA2-3: JP11.15, JP15.2
PA3: IC3.37 (PA3), PA3.1, R54.1
PA3-2: JP2.1, JP10.16
PA3-3: JP11.16, JP15.1
PA3_1: JP1.1, JP9.16
PA4: IC3.40 (PA4), PA4.1, R59.1
PA5: IC3.41 (PA5), PA5.1, R65.1
PA6: IC3.42 (PA6), PA6.1, R70.1
PA7: IC3.43 (PA7), PA7.1, R75.1
PA8: IC3.100 (PA8)
PA9: IC3.101 (PA9)
PA10: IC3.102 (PA10)
PA11: IC3.103 (PA11)
PA12: IC3.104 (PA12)
PB0: IC3.46 (PB0), PB0.1, R97.1
PB1: IC3.47 (PB1), PB1.1, R102.1
PB5: IC3.135 (PB5)
PB6: IC3.136 (PB6)
PB7: IC3.137 (PB7)
PB8: IC3.139 (PB8), PB8.1
PB9: IC3.140 (PB9), PB9.1
PB12: IC3.73 (PB12), J10.2
PB13: IC3.74 (PB13), J10.1
PB14: IC3.75 (PB14), J10.3
PB15: IC3.76 (PB15), J10.4
PC4: IC3.44 (PC4), PC4.1, R85.1
PC5: IC3.45 (PC5), PC5.1, R92.1
PC6: IC3.96 (PC6)
PC7: IC3.97 (PC7)
PC14: IC3.8 (PC14/OSC32_IN)
PC15: IC3.9 (PC15/OSC32_OUT)
PD3: IC3.117 (PD3)
PD4: IC3.118 (PD4)
PD7: IC3.123 (PD7), R107.2
PD11: IC3.80 (PD11), R82.2, R86.2, R87.2, R108.2
PD12: IC3.81 (PD12)
PD13: IC3.82 (PD13)
PF6: IC3.18 (PF6)
PF7: IC3.19 (PF7)
PF8: IC3.20 (PF8)
PF9: IC3.21 (PF9)
PF10: IC3.22 (PF10)
PG6: IC3.91 (PG6)
PG7: IC3.92 (PG7)
PG9: IC3.124 (PG9), R109.1
PG10: IC3.125 (PG10), R106.1
PG11: IC3.126 (PG11), R105.1
PG12: IC3.127 (PG12)
SAI1_FS_A: R82.1, R83.1
SAI1_MCLK_A: R62.1, R87.1
SAI1_SCK_A: R81.1, R86.1
SAI1_SD_A: R84.1, R108.1
SAI1_SD_B: IC3.2 (PE3)
SCL_B: U2.56 (P15[3]), U19.22 (SCL); also elsewhere on the board
SDA_B: U2.55 (P15[2]), U19.23 (SDA); also elsewhere on the board
SPI1_CS: JP9.17, JP10.17, JP11.17, X7.9
SPI1_CS_B: J15.2, R201.1, X9.9
SPI1_MISO: JP9.19, JP10.19, JP11.19, R208.1
SPI1_MISO_B: J15.3, U2.42 (P15[0]), X9.11
SPI1_MISO_OUT: J8.3, R109.2
SPI1_MOSI: JP9.20, JP10.20, JP11.20, X7.12
SPI1_MOSI_B: J15.4, R207.1, X9.12
SPI1_MOSI_OUT: J8.4, R107.1
SPI1_NSS_OUT: J8.2, R106.2
SPI1_SCK: JP9.18, JP10.18, JP11.18, X7.10
SPI1_SCK_OUT: J8.1, R105.2
SPI1_SCLK_B: J15.1, R200.1, X9.10
SPI2_CS: JP6.3, JP7.3, JP8.3, X7.13
SPI2_CS_B: J14.2, U2.49 (P3[5]), X9.13
SPI2_MISO: JP6.5, JP7.5, JP8.5, R209.1
SPI2_MISO_B: J14.3, U2.46 (P3[2]), X9.15
SPI2_MOSI: JP6.6, JP7.6, JP8.6, X7.16
SPI2_MOSI_B: J14.4, U2.47 (P3[3]), X9.16
SPI2_SCK: JP6.4, JP7.4, JP8.4, X7.14
SPI2_SCLK_B: J14.1, U2.48 (P3[4]), X9.14
SPI3_BOOTLOAD_MISO: J2.3, R202.1
SPI3_BOOTLOAD_MOSI: IC3.113 (PC12), J2.4
SPI3_BOOTLOAD_NSS: IC3.110 (PA15(JTDI)), J2.2
SPI3_BOOTLOAD_SCK: IC3.111 (PC10), J2.1
SPI3_CS_B: J13.2, U2.19 (P5[3]), X9.5
SPI3_MISO_B: J13.3, U2.16 (P5[0]), X9.7
SPI3_MOSI_B: J13.4, U2.17 (P5[1]), X9.8
SPI3_SCLK_B: J13.1, U2.18 (P5[2]), X9.6
SPI5_CS: JP9.9, JP10.9, JP11.9, X7.5
SPI5_MISO: JP9.7, JP10.7, JP11.7, R112.1
SPI5_MOSI: JP9.8, JP10.8, JP11.8, X7.8
SPI5_SCK: JP9.10, JP10.10, JP11.10, X7.6
SWCLK: IC3.109 (PA14(JTCK/SWCLK)), X2.4
SWDIO: IC3.105 (PA13(JTMS-SWDIO)), X2.2
SWDRESET: C5.1, IC3.25 (~RST), X2.10
SWD_CK_2: U1.21 (P1[1]), X3.4
SWD_CK_3: U2.21 (P1[1]), X1.4
SWD_IO_2: U1.20 (P1[0]), X3.2
SWD_IO_3: U2.20 (P1[0]), X1.2
SWO: IC3.133 (PB3(JTDO/TRACESWO)), X2.6
TOPWIPER1: R113.1, U1.74 (P0[3])
TOPWIPER2: J42.19, U1.73 (P0[2])
TOUCH1: X6.1
TOUCH2: X6.2
TOUCH3: X6.3
TOUCH4: X6.4
TOUCH5: X6.5
TOUCH6: X6.6
TOUCH7: X6.7
TOUCH8: X6.8
TOUCH9: X6.9
TOUCH10: X6.10
TOUCH11: X6.11
TOUCH12: X6.12
USB_VBUS: R156.1, R157.2, U2.77 (P0[5])
VBUS: JP19.7, R156.2
VCAP1: C19.1, IC3.71 (VCAP), IC3.106 (VCAP)
VCCD0_2: C131.1, C132.1, U1.39 (VCCD0), U1.86 (VCCD1)
VCCD0_3: C139.1, C140.1, U2.39 (VCCD0), U2.86 (VCCD1)
VOUT1: R113.2, U1.71 (P0[0])
VOUT2: R114.2, U1.72 (P0[1])
VOUT3: R115.2, U1.51 (P3[6])
VOUT4: R120.1, U1.52 (P3[7])
VREF: C64.1, IC3.32 (VREF+), R4.2
XRES_2: U1.15 (~XRES), X3.10
XRES_3: U2.15 (~XRES), X1.10

Notes on the sheet:
DW-12-08-L-D-215 and ESW-112-12-L-D for 24 pin
pb1
lmv611
DW-05-08-L-D-215 and ESW-105-12-L-D for 10 pin
lnj426W83RA - 10ma
pwr
vr20s05
01 = 1
pc5
LVM614
need wider rails here - opa1654 is good and only $2.83
10 = 2
VR20S05
0 0 = 0
don't actually need high current here
adafruit 4090 usb-c connector
0.05" SWD 10-pin
actually 15v / -15v out
produce linear +-12v for opamp

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